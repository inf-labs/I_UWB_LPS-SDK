# Keil uVision project i_uwb_dt-sdk.uvprojx, settings and files
target i_uwb_dt-sdk (ARM-ADS)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.6.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: i_uwb_dt-sdk +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\src\app;..\src\lib\inf_lib;..\src\lib\st_lib\CMSIS\Include;..\src\lib\st_lib\CMSIS\Include\Include;..\src\lib\st_lib\STM32F4xx_StdPeriph_Driver\inc;..\src\lib\st_lib\CMSIS;..\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group app
    ../src/app/: main.c stm32f4xx_it.c system_init.c task.c i_uwb_lps.c
  group bsp
    ../src/bsp/delay/: delay.c
    ../src/bsp/usart/: usart1.c
    ../src/bsp/key/: key.c
    ../src/bsp/led/: led.c
    ../src/bsp/system/: system_param.c
    ../src/bsp/systick/: systick.c
  group ilink
    ../src/modules/ilink/: ilink.c ilink_i_uwb_lps.c ilink_ahrs.c
  group inf_lib
    ../src/lib/inf_lib/: inf_math_lib.c
  group st_lib
    ../src/lib/st_lib/CMSIS/: system_stm32f4xx.c startup_stm32f4xx.s
    ../src/lib/st_lib/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
